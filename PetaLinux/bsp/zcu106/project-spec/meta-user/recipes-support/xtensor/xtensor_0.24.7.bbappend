# Same issue as xtl: branch=master no longer reaches SRCREV.
SRC_URI = "git://github.com/xtensor-stack/xtensor.git;protocol=https;nobranch=1"
